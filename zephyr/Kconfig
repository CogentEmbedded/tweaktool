## zephyr/Kconfig
```kconfig
# SPDX-License-Identifier: MIT

config TWEAKTOOL
	bool "Enable support for tweaktool"
```
